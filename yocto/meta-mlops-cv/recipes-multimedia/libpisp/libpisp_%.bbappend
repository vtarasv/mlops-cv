# The libcamera fork's subprojects/libpisp.wrap names v1.5.0.
PV = "1.5.0"
SRCREV = "86d71c805c3f96ca6b304a404a753b3fff44c85b"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3417a46e992fdf62e5759fba9baef7a7 \
                    file://LICENSES/GPL-2.0-only.txt;md5=b234ee4d69f5fce4486a80fdaf4a4263 \
                    file://LICENSES/GPL-2.0-or-later.txt;md5=261bea1168c0bdfa73232ee90df11eb6"
